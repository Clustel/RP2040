# Repository Clustel/RP2040

File README.md:

# Mocon
A dev board with an upgraded LDO compared to other traditional devboards, which will allow for using devices that need higher current draw. 

I made this to allow for easier prototyping as it gives extra breathing space when prototyping with many components connected at once to a dev board.

# Features
	RP2040 chip
	29 GPIO pins
	12Mhz Crystal
	High current LDO

# Schematic

# PCB	

# Ordering
Upload the zipped Prod folder to JLCPCB and go through their steps for a PCBA.

# BOM if u want to solder it on your own (might be more expensive than PCBA)
| Id | Designator | Footprint | Quantity | Comment |
| --- | --- | --- | --- | --- |
| 1 | C6,C12,C3,C17,C8,C5,C4,C7,C11,C2,C9 | C_0402_1005Metric | 11 | .1uF |
| 2 | C1,C10 | C_0402_1005Metric | 2 | 1uF |
| 3 | R7,R5 | C_0402_1005Metric | 2 | 1k |
| 4 | U2 | SOT-23-5 | 1 | AP2112K-3.3 |
| 5 | C13,C14 | C_0603_1608Metric | 2 | 10uF |
| 6 | C16,C15 | C_0402_1005Metric | 2 | 33pF |
| 7 | R2,R1 | C_0402_1005Metric | 2 | 5.1k |
| 8 | J1 | USB_C_Receptacle_HRO_TYPE-C-31-M-12 | 1 | USB_C_Receptacle_USB2.0_14P |
| 9 | SW1 | SW_Push_SPST_NO_Alps_SKRK | 1 | SW_Push |
| 10 | Y1 | Crystal_SMD_3225-4Pin_3.2x2.5mm | 1 | 12 MHz |
| 11 | R3,R4 | C_0402_1005Metric | 2 | 27 |
| 12 | U1 | QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm | 1 | RP2040 |
| 13 | R6 | C_0402_1005Metric | 1 | 10k |
| 14 | J4 | PinHeader_1x03_P2.54mm_Vertical | 1 | Conn_01x03 |
| 15 | U3 | Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm | 1 | W25Q16JVZPIQ TR |
| 16 | J2,J3 | PinHeader_1x20_P2.54mm_Vertical | 2 | Conn_01x20 |

# Silk Screen Sneak Peeks ;)

## KiCad design RP2040 Devboard/RP2040 Devboard.kicad_pcb

Parts:
C1, C10: 1uF; C_0402_1005Metric
C2, C3, C4, C5, C6, C7, C8, C9, C11, C12, C17: .1uF; C_0402_1005Metric
C13, C14: 10uF; C_0603_1608Metric
C15, C16: 33pF; C_0402_1005Metric
J1: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J3: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 5.1k; C_0402_1005Metric
R3, R4: 27; C_0402_1005Metric
R5, R7: 1k; C_0402_1005Metric
R6: 10k; C_0402_1005Metric
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U2: AP2112K-3.3; SOT-23-5
U3: W25Q16JVZPIQ TR; Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm
Y1: 12 MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C10.1, C11.1, C12.1, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C13.1, C17.2, J3.5, R6.1, U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.33 (IOVDD), U1.42 (IOVDD), U1.43 (ADC_AVDD), U1.44 (VREG_VIN), U1.48 (USB_VDD), U1.49 (IOVDD), U2.5 (VOUT), U3.8 (VCC)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.3, J2.7, J2.13, J2.18, J3.3, J3.8, J3.13, J3.18, J4.2, R1.2, R2.2, SW1.1, U1.19 (TESTEN), U1.57 (GND), U2.2 (GND), U3.4 (GND), U3.9 (EP), Y1.2 (G), Y1.4 (G)
GPIO0: J2.1, U1.2 (GPIO0)
GPIO1: J2.2, U1.3 (GPIO1)
GPIO2: J2.4, U1.4 (GPIO2)
GPIO3: J2.5, U1.5 (GPIO3)
GPIO4: J2.6, U1.6 (GPIO4)
GPIO5: J2.8, U1.7 (GPIO5)
GPIO6: J2.9, U1.8 (GPIO6)
GPIO7: J2.10, U1.9 (GPIO7)
GPIO8: J2.11, U1.11 (GPIO8)
GPIO9: J2.12, U1.12 (GPIO9)
GPIO10: J2.14, U1.13 (GPIO10)
GPIO11: J2.15, U1.14 (GPIO11)
GPIO12: J2.16, U1.15 (GPIO12)
GPIO13: J2.17, U1.16 (GPIO13)
GPIO14: J2.19, U1.17 (GPIO14)
GPIO15: J2.20, U1.18 (GPIO15)
GPIO16: J3.20, U1.27 (GPIO16)
GPIO17: J3.19, U1.28 (GPIO17)
GPIO18: J3.17, U1.29 (GPIO18)
GPIO19: J3.16, U1.30 (GPIO19)
GPIO20: J3.15, U1.31 (GPIO20)
GPIO21: J3.12, U1.32 (GPIO21)
GPIO22: J3.11, U1.34 (GPIO22)
GPIO23: J3.10, U1.35 (GPIO23)
GPIO24: J3.9, U1.36 (GPIO24)
GPIO26_ADC0: J3.7, U1.38 (GPIO26/ADC0)
GPIO27_ADC1: J3.6, U1.39 (GPIO27/ADC1)
GPIO28_ADC2: J3.4, U1.40 (GPIO28/ADC2)
GPIO29_ADC3: J3.2, U1.41 (GPIO29/ADC3)
unnamed: C16.2, R5.2, Y1.1
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: R7.1, SW1.2
unnamed: R3.1, U1.46 (USB_DN)
unnamed: R4.1, U1.47 (USB_DP)
QSPI_SCLK: U1.52 (QSPI_SCLK), U3.6 (CLK)
QSPI_SD0: U1.53 (QSPI_SD0), U3.5 (DI/IO_{0})
QSPI_SD1: U1.55 (QSPI_SD1), U3.2 (DO/IO_{1})
QSPI_SD2: U1.54 (QSPI_SD2), U3.3 (~WP/IO_{2})
QSPI_SD3: U1.51 (QSPI_SD3), U3.7 (~HOLD/~RESET/IO_{3})
QSPI_SS: R6.2, R7.2, U1.56 (~QSPI_SS), U3.1 (~CS)
RUN: J3.14, U1.26 (RUN)
SWCLK: J4.1, U1.24 (SWCLK)
SWD: J4.3, U1.25 (SWDIO)
USB_DN: J1.A7 (D-), J1.B7 (D-), R3.2
USB_DP: J1.A6 (D+), J1.B6 (D+), R4.2
VBUS: C14.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J3.1, U2.1 (VIN), U2.3 (EN)
XIN: C15.2, U1.20 (XIN), Y1.3
XOUT: R5.1, U1.21 (XOUT)

Board: 2 copper layers, 21.0 x 51.0 mm, 33 parts (0 on the bottom side), 52 nets.

## Commit log

2026-03-14 All PCB files added
2026-03-14 Add project description to README
2026-03-14 Update README with ordering details
    Added ordering information for the RP2040 Dev Board.
2026-03-14 Fix formatting in README.md
2026-05-16 Revise README with project details and features
    Updated project description and added features section.
